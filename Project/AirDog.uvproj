# Keil uVision project AirDog.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AirDog +hex
  AfterMake: C:/Keil_v5/ARM/ARMCC/bin/fromelf.exe --bin -o ./List/AirDog.bin ./Obj/AirDog.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,
  c include: ..\Library\inc;..\System\CMSIS;..\System\startup;..\OS\inc;..\User\inc;..\Component\RegLib\inc;..\Component\Gizwits\src;..\Component\Gizwits\port;..\Component\Gizwits\Utils;..\Component\Sensor\inc;..\Component\USB\UsbApp;..\Component\USB\Usb_LIB\inc;..\Component\USB\LIB\inc;..\Component\SFUD-master\others;..\Component\SFUD-master\sfud\inc;..\Component\FatFs\option;..\Component\FatFs\inc;..\Component\TFTLib\ILI9341\inc;..\Component\UGUI\UGUI-master;..\Component\TFTLib\ILI9341_4Line\inc;..\Dev\Driver\inc;..\Dev\CPU;..\Dev\BSP;..\Component\SD_CARD;..\Component\FIFO_QUEUE
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Library
    ../Library/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_pwr.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_sdio.c
    ../Library/inc/: misc.h stm32f10x_gpio.h stm32f10x_fsmc.h stm32f10x_rcc.h
  group User
    ../User/src/: stm32f10x_it.c Application.c main.c SDRR.c cfg_variable.c
  group Driver
    ../OS/src/: os_global.c os_timer.c
    ../Dev/Driver/src/: delay.c F10X_Flash_If.c IIC_Drv.c ILI9341_4Line_SPI.c Key_Drv.c rom_flash_interface.c RTCDrv.c sd_card_interface.c spi_flash_interface.c TFT_API.c timer_drv.c Uart_Drv.c TimerManager.c SW_UART.c SW_UART2.c ExtiDrv.c PCF8563.c queue.c debug_queue.c PWM.c beep_drv.c wifi_queue.c flash_font.c PWM_TIM5.c debugfile.c bat_adc.c bat_handle.c
  group CMSIS
    ../System/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group startup
    ../System/startup/: startup_stm32f10x_hd.s
  group RegLib
    ../Component/RegLib/src/: RegLib.c sys.c
  group Gizwits
    ../Component/Gizwits/port/: gizwits_port.c gizwits_uart.c
    ../Component/Gizwits/src/: gizwits_product.c gizwits_protocol.c
    ../Component/Gizwits/Utils/: common.c dataPointTools.c ringbuffer.c
  group Sensor
    ../Component/Sensor/src/: CO_Sensor.c CO2_Sensor.c hcho_sensor.c PM25_Sensor.c sensor.c SHT20.c stm32f1_temp_sensor.c TVOCSensor.c co2.c
  group FatFS
    ../Component/FatFs/option/: syscall.c ccsbcs.c
    ../Component/FatFs/src/: diskio.c fatfs_demo.c ff.c
  group USB_lib
    ../Component/USB/Usb_LIB/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB
    ../Component/USB/UsbApp/: UsbApp.c
    ../Component/USB/LIB/src/: disk_image.c hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group SFUD
    ../Component/SFUD-master/sfud/port/: sfud_port.c
    ../Component/SFUD-master/sfud/src/: sfud.c sfud_sfdp.c
    ../Component/SFUD-master/others/: sfud_demo.c bsp.c
  group TFTLib
    ../Component/TFTLib/ILI9341/src/: tft_core.c tft_demo.c tft_dma.c tft_encoder.c tft_graph.c tft_itoa.c tft_text.c
    ../Component/TFTLib/ILI9341_4Line/src/: Font1.c QDTFT_demo.c SnsGUI.c UserGUI.c FONT_API.c
  group UGUI
    ../Component/UGUI/UGUI-master/: ugui.c UGUI_Demo.c ugui_font.c
  group SD_CARD
    ../Component/SD_CARD/: sdio_sdcard.c
  group BSP
    ../Dev/BSP/: board_AirDog_V13.c
  group FIFO_QUEUE
    ../Component/FIFO_QUEUE/: fifo_queue.c
